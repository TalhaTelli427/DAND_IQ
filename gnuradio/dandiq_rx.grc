options:
  parameters:
    author: jason
    generate_options: qt_gui
    id: lesson21_QPSK_modem
    output_language: python
    title: lesson21_QPSK_modem
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.350'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {state: disabled}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '60'
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 0.2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: tx_pwr
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '73'
    value: '70'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      Skip one second of samples
      to allow AGC and FLL to lock
    num_items: int(samp_rate)
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constellation.bits_per_symbol()
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      Input comes from Symbol Sync
      Includes a Costas Loop to do phase sync
    constellation: constellation
    fmax: math.pi
    fmin: '-math.pi'
    loop_bw: 2*math.pi/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constellation.arity()
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100/sps
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      If using Polyphase Ffilterbank, MF, it does the
      matched filtering for you, but you need to 
      pass in properly constructed RRC filter taps
      TODO: try the others, but with explicit RRC matched filtering
         don't bother with M&M
    constellation: constellation
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '.1'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2345'
    send_eof: 'False'
    type: byte
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0
    bb_gain0: '20'
    bw0: 2e6
    corr0: '1'
    dc_offset_mode0: '2'
    freq0: center_freq+1e6
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    time_source0: gpsdo
    type: fc32
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    label1: Sync
    label2: Costas
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    label1: Receive Raw
    label2: Receive FLL Band-Edge
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: '1024'
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Receive Raw Re
    label2: Receive Raw Im
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: Constellation Receiver Decoded
    marker1: '0'
    size: '100'
    srate: samp_rate
    type: float
    ymax: constellation.arity()-1+0.2
    ymin: '-.2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Sync T_inst
    label2: Sync T_avg
    nconnections: '2'
    size: 1024*8
    srate: samp_rate
    type: float
    ymax: sps*1.01
    ymin: sps*0.99
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_1_0, '0']
- [blocks_skiphead_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', qtgui_time_raster_sink_x_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_1, '1']
- [digital_diff_decoder_bb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', network_udp_sink_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_1, '0']
- [digital_symbol_sync_xx_0, '1', blocks_null_sink_0_1, '0']
- [digital_symbol_sync_xx_0, '2', qtgui_time_sink_x_0_0_0_0_0_0_1_0_0, '0']
- [digital_symbol_sync_xx_0, '3', qtgui_time_sink_x_0_0_0_0_0_0_1_0_0, '1']
- [osmosdr_source_0, '0', analog_agc_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
